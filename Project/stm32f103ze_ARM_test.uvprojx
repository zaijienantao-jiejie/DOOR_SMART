# Keil uVision project stm32f103ze_ARM_test.uvprojx, settings and files
target test (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103ze_ARM_test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libs\STM32F10x_StdPeriph_Driver\inc;..\Libs\CMSIS\CM3\CoreSupport;..\Libs\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\User;..\Drivers\BEEP;..\Drivers\Delay;..\Drivers\Door_access;..\Drivers\RC522;..\Drivers\Timer;..\Drivers\USART;..\Drivers\SERVO;..\Drivers\AS608;..\Drivers\AS608_USART;..\Drivers\W25QXX;..\Drivers\OLED;..\Drivers\KeyPad;..\Drivers\ESP8266;..\Middleware\FreeRTOS\include;..\Middleware\FreeRTOS\portable\RVDS\ARM_CM3;..\Drivers\LED;..\Drivers\APP_UI;..\Drivers\APP_STATE;..\Drivers\Power
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c stm32f10x_it.c freertos_test.c
    ../Libs/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    D:/peixun/smart_door/Middleware/FreeRTOS/include/: FreeRTOSConfig.h
  group Drivers
    ../Drivers/BEEP/: beep.c
    ../Drivers/door_access/: door_access.c
    ../Drivers/rc522/: rc522.c
    ../Drivers/USART/: usart.c
    ../Drivers/APP_UI/: app_ui.c
    ../Drivers/Timer/: timer.c
    ../Drivers/Delay/: delay.c
    ../Drivers/SERVO/: servo.c
    ../Drivers/ESP8266/: esp8266.c
    ../Drivers/AS608_USART/: as608_uart.c
    ../Drivers/AS608/: as608.c
    ../Drivers/W25QXX/: w25qxx.c
    ../Drivers/KeyPad/: keypad.c
    ../Drivers/OLED/: OLED.c
    ../Drivers/LED/: led.c
    ../Libs/STM32F10x_StdPeriph_Driver/src/: stm32f10x_pwr.c
    ../Drivers/APP_STATE/: app_state.c
    ../Drivers/Power/: power.c
  group FWlibs
    ../Libs/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Startup
    ../Libs/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group FreeRTOS_CORE
    ../Middleware/FreeRTOS/portable/MemMang/: heap_4.c
    ../Middleware/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group FreeRTOS_PORT
    ../Middleware/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
